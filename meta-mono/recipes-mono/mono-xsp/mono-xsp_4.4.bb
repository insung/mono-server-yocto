require mono-xsp-4.x.inc
 
 SRC_URI[md5sum] = "d831bc43e81951f48849a62b2da75ea3"