require mono-xsp-4.x.inc

SRCREV= "d831bc43e81951f48849a62b2da75ea3"
SRC_URI = "git://github.com/mono/xsp.git \
	  "

S = "${WORKDIR}/git"
